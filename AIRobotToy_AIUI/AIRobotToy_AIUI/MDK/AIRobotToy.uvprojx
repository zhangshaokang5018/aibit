# Keil uVision project AIRobotToy.uvprojx, settings and files
target AIRobotToy (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AIRobotToy +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM
  c misc: --locale=english
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\MDK;..\Peripherals;..\FreeRTOS\include;..\Fatfs;..\Audio;..\Audio\player;..\Audio\recorder;..\Audio\recorder\webrtc;..\Audio\player\mp3\HelixMP3Decoder\pub;..\Audio\player\mp3\HelixMP3Decoder\real;..\Audio\player\mp3;..\Audio\player\wav;..\Shell;..\Public;..\Network;..\Led;..\Libraries\DSP_LIB\Include;..\AudioSet;..\BlueTooth;..\Peripherals
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/Device/Source/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DSP_LIB
    ../Libraries/DSP_LIB/: arm_cortexM4lf_math.lib
  group Peripherals
    ../Peripherals/: usart.c sotf_iic.c rtc.c sdio_sd.c spi_i2s.c wdog.c iflash.c timer.c myiic.c delay.c usart3.c L298N.c L298N.h sr04.c sr04.h
  group HelixMP3Decoder
    ../Audio/player/mp3/HelixMP3Decoder/: mp3dec.c mp3tabs.c
    ../Audio/player/mp3/HelixMP3Decoder/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../Audio/player/mp3/HelixMP3Decoder/real/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group Audio
    ../Audio/: audio.c wm8978.c
    ../Audio/player/: player.c
    ../Audio/player/wav/: wavplay.c
    ../Audio/player/mp3/: mp3play.c
    ../Audio/recorder/: recorder.c
  group Led
    ../Led/: led.c
  group Fatfs
    ../Fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/: heap_5.c
  group Network
    ../Network/: esp8266.c serial_AT.c network.c netlsn.c netvoc.c urlencode.c netcmd.c
  group Shell
    ../Shell/: cmd.c read-line.c shell.c
  group Public
    ../Public/: stm32f4xx_it.c main.c bsp_init.c syslog.c NTP.h base64.c md5.c base64.h md5.h
  group BlueTooth
    ../BlueTooth/: ble.c
  group Readme
    ../: 使用说明.txt
